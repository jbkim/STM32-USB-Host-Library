# IAR project binary_template.ewp, settings and files
configuration STM322xG-EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207xx ST STM32F207xx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F2XX; USE_STM322xG_EVAL
  ICCARM.CCIncludePath2: ..\; ..\inc; ..\..\..\..\..\Libraries\CMSIS\Device\ST\STM32F2xx\Include; ..\..\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc; ..\..\..\..\..\Utilities\STM32_EVAL; ..\..\..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\..\..\Utilities\STM32_EVAL\STM322xG_EVAL
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM3220G_EVAL_Systick_0x0800C000.hex
  ILINK.IlinkOutputFile: STM322xG-EVAL.out
  ILINK.IlinkIcfFile: stm32f2xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM3210C-EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F107xC ST STM32F107xC
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; USE_STM3210C_EVAL
  ICCARM.CCIncludePath2: ..\; ..\inc; ..\..\..\..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include; ..\..\..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\..\..\Utilities\STM32_EVAL; ..\..\..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\..\..\Utilities\STM32_EVAL\STM3210C_EVAL
  OBJCOPY.OOCOutputFile: STM3210C_EVAL_Systick_0x08008000.hex
  ILINK.IlinkOutputFile: STM3210C-EVAL.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
configuration STM324xG-EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F4xxx ST STM32F4xxx
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX; USE_STM324xG_EVAL
  ICCARM.CCIncludePath2: ..\; ..\inc; ..\..\..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\..\..\Utilities\STM32_EVAL; ..\..\..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\..\..\Utilities\STM32_EVAL\STM3240_41_G_EVAL
  OBJCOPY.OOCOutputFile: STM3240G_EVAL_Systick_0x0800C000.hex
  ILINK.IlinkOutputFile: STM324xG-EVAL.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  group App
    ../src/: app.c stm32fxxx_it.c
  group STM32_EVAL
    ../../../../../Utilities/STM32_EVAL/Common/: lcd_log.c
  group STM32F10x
    ../../../../../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/iar/: startup_stm32f10x_cl.s
    ../src/: system_stm32f10x.c
  group STM32F10x/STM3210C_EVAL
    ../../../../../Utilities/STM32_EVAL/STM3210C_EVAL/: stm3210c_eval.c stm3210c_eval_lcd.c
  group STM32F10x/STM32F10x_StdPeriph_Driver
    ../../../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_spi.c
  group STM32F2xx
    ../../../../../Libraries/CMSIS/Device/ST/STM32F2xx/Source/Templates/iar/: startup_stm32f2xx.s
    ../src/: system_stm32f2xx.c
  group STM32F2xx/STM322xG_EVAL
    ../../../../../Utilities/STM32_EVAL/STM322xG_EVAL/: stm322xg_eval.c stm322xg_eval_lcd.c
  group STM32F2xx/STM32F2xx_StdPeriph_Driver
    ../../../../../Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_i2c.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_syscfg.c
  group STM32F4xx
    ../../../../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f4xx.s
    ../src/: system_stm32f4xx.c
  group STM32F4xx/STM324xG_EVAL
    ../../../../../Utilities/STM32_EVAL/STM3240_41_G_EVAL/: stm324xg_eval.c stm324xg_eval_lcd.c
  group STM32F4xx/STM32F4xx_StdPeriph_Driver
    ../../../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_syscfg.c
